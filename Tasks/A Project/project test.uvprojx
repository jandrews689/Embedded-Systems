# Keil uVision project project test.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../Task-360A-Polling/: main.cpp .gitignore .mbed libuopmsb.lib mbed_app.json mbed-os.lib README.md SWPoll.hpp
    ../HelloWorld/mbed-os/: mbed.h
software components: CMSIS:CORE 6.1.0, Device:CubeMX 1.0.0
